Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_576/temp/tmp_1656_48_K9clz/format_1/3253(architecture=300).ifc
Time: 2025-09-01T09:05:57
Made in: PARTsolutions

# IfcProject, 3253(architecture=300)
Description: ALUVIA

# IfcDiscreteAccessory, 3253(architecture=300)
In: BUILDING
Description: 3253(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 3253
ePset_PARTsolutions - NB: 3253(architecture=300); NN: 3253; NT: ALUVIA; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 3253(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 3253; B: 3253_aluvia_900x900.png; C: ALUVIA; E: KALDEWEI; EF000049: 900; EF004567: 900; etim7_EC003246: EC003246; etim7_EC003246_WIDTH: 900; etim7_EC003246_LENGTH: 900
